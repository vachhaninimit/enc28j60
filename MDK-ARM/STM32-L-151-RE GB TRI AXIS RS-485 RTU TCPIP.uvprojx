# Keil uVision project STM32-L-151-RE GB TRI AXIS RS-485 RTU TCPIP.uvprojx, settings and files
target STM32-L-151-RE GB TRI AXIS RS-485 RTU TCPIP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L151RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32-L-151-RE GB TRI AXIS RS-485 RTU TCPIP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L151xE
  c include: ../Core/Inc;  ../Drivers/STM32L1xx_HAL_Driver/Inc;  ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;  ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/MDK-ARM
    ./: startup_stm32l151xe.s
  group Application/User/Core
    ../Core/Src/: enc28j60.c ethernetif.c eeprom.c udp_server.c uart.c main.c stm32l1xx_it.c stm32l1xx_hal_msp.c tcp_server.c modbus_rtu.c calibration.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_spi.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
software components: CMSIS:CORE 5.4.0, Network:CORE 2.1.2, Network:Interface:Ethernet 2.1.2
